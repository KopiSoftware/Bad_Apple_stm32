# Keil uVision project bad_apple.uvprojx, settings and files
target bad_apple (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bad_apple +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\PROJECT;..\LIBRARIES\delay;..\LIBRARIES\LED;..\LIBRARIES\OLED;..\LIBRARIES\sys;..\LIBRARIES\usart;..\STM32LIB\inc;..\STM32LIB\CMSIS\startup;..\STM32LIB\CMSIS;..\STM32LIB;..\LIBRARIES;..\LIBRARIES\FATFS;..\LIBRARIES\FATFS\exfuns;..\LIBRARIES\FATFS\src;..\LIBRARIES\SDIO;..\LIBRARIES\SDIO;..\LIBRARIES\MALLOC;..\LIBRARIES\W25QXX;..\LIBRARIES\SPI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group PROJECT
    ./: main.c
  group LIBRARIES
    ../LIBRARIES/delay/: delay.c
    ../LIBRARIES/LED/: led.c
    ../LIBRARIES/OLED/: OLED_I2C.c
    ../LIBRARIES/sys/: sys.c
    ../LIBRARIES/usart/: usart.c
    ../LIBRARIES/FATFS/src/: diskio.c ff.c
    ../LIBRARIES/FATFS/src/option/: cc936.c
    ../LIBRARIES/FATFS/exfuns/: exfuns.c
    ../LIBRARIES/SDIO/: sdio_sdcard.c
    ../LIBRARIES/MALLOC/: malloc.c
    ../LIBRARIES/W25QXX/: w25qxx.c
    ../LIBRARIES/SPI/: spi.c
  group STM32LIB
    ../STM32LIB/: stm32f10x_it.c
    ../STM32LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../STM32LIB/CMSIS/: core_cm3.c system_stm32f10x.c
    ../STM32LIB/CMSIS/startup/: startup_stm32f10x_hd.s
